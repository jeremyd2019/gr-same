<?xml version='1.0' encoding='utf-8'?>
<?grc format='1' created='3.7.5'?>
<flow_graph>
<block>
<key>options</key>
<param><key>id</key><value>top_block</value></param>
<param><key>generate_options</key><value>wx_gui</value></param>
<param><key>category</key><value>Custom</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>samp_rate</value></param>
<param><key>value</key><value>250000</value></param>
</block>
<block>
<key>audio_sink</key>
<param><key>id</key><value>audio_sink_0_0</value></param>
<param><key>samp_rate</key><value>44100</value></param>
<param><key>num_inputs</key><value>2</value></param>
</block>
<block>
<key>wxgui_waterfallsink2</key>
<param><key>id</key><value>wxgui_waterfallsink2_0</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>title</key><value>Waterfall Plot</value></param>
<param><key>samp_rate</key><value>samp_rate</value></param>
<param><key>baseband_freq</key><value>162.487e6</value></param>
<param><key>dynamic_range</key><value>100</value></param>
<param><key>ref_level</key><value>0</value></param>
<param><key>ref_scale</key><value>2.0</value></param>
<param><key>fft_size</key><value>512</value></param>
<param><key>fft_rate</key><value>15</value></param>
<param><key>average</key><value>False</value></param>
<param><key>avg_alpha</key><value>0</value></param>
<param><key>win</key><value>None</value></param>
<param><key>freqvar</key><value>None</value></param>
</block>
<block>
<key>blocks_file_sink</key>
<param><key>id</key><value>blocks_file_sink_0</value></param>
<param><key>file</key><value>testsea.dat</value></param>
<param><key>type</key><value>byte</value></param>
</block>
<block>
<key>blocks_file_sink</key>
<param><key>id</key><value>blocks_file_sink_0_0</value></param>
<param><key>file</key><value>testps.dat</value></param>
<param><key>type</key><value>byte</value></param>
</block>
<block>
<key>freq_xlating_fir_filter_xxx</key>
<param><key>id</key><value>freq_xlating_fir_filter_xxx_0</value></param>
<param><key>type</key><value>ccc</value></param>
<param><key>decim</key><value>5</value></param>
<param><key>taps</key><value>firdes.low_pass(1, samp_rate, 5000, 1500)</value></param>
<param><key>center_freq</key><value>-62.4e3</value></param>
<param><key>samp_rate</key><value>samp_rate</value></param>
</block>
<block>
<key>pfb_arb_resampler_xxx</key>
<param><key>id</key><value>pfb_arb_resampler_xxx_1</value></param>
<param><key>type</key><value>ccf</value></param>
<param><key>rrate</key><value>44100/50000.0</value></param>
<param><key>nfilts</key><value>32</value></param>
<param><key>atten</key><value>100</value></param>
</block>
<block>
<key>freq_xlating_fir_filter_xxx</key>
<param><key>id</key><value>freq_xlating_fir_filter_xxx_1</value></param>
<param><key>type</key><value>ccc</value></param>
<param><key>decim</key><value>5</value></param>
<param><key>taps</key><value>firdes.low_pass(1, samp_rate, 5000, 1500)</value></param>
<param><key>center_freq</key><value>62.5e3</value></param>
<param><key>samp_rate</key><value>samp_rate</value></param>
</block>
<block>
<key>pfb_arb_resampler_xxx</key>
<param><key>id</key><value>pfb_arb_resampler_xxx_0</value></param>
<param><key>type</key><value>ccf</value></param>
<param><key>rrate</key><value>44100/50000.0</value></param>
<param><key>nfilts</key><value>32</value></param>
<param><key>atten</key><value>100</value></param>
</block>
<block>
<key>pfb_arb_resampler_xxx</key>
<param><key>id</key><value>pfb_arb_resampler_xxx_3</value></param>
<param><key>type</key><value>fff</value></param>
<param><key>rrate</key><value>11050/44100.0</value></param>
<param><key>nfilts</key><value>32</value></param>
<param><key>atten</key><value>100</value></param>
</block>
<block>
<key>same_same_decode_fb</key>
<param><key>id</key><value>same_same_decode_fb_0</value></param>
<param><key>samp_rate</key><value>11050</value></param>
</block>
<block>
<key>same_same_decode_fb</key>
<param><key>id</key><value>same_same_decode_fb_0_0</value></param>
<param><key>samp_rate</key><value>11050</value></param>
</block>
<block>
<key>pfb_arb_resampler_xxx</key>
<param><key>id</key><value>pfb_arb_resampler_xxx_2</value></param>
<param><key>type</key><value>fff</value></param>
<param><key>rrate</key><value>11050/44100.0</value></param>
<param><key>nfilts</key><value>32</value></param>
<param><key>atten</key><value>100</value></param>
</block>
<block>
<key>analog_nbfm_rx</key>
<param><key>id</key><value>analog_nbfm_rx_1_0</value></param>
<param><key>audio_rate</key><value>44100</value></param>
<param><key>quad_rate</key><value>44100</value></param>
<param><key>tau</key><value>75e-6</value></param>
<param><key>max_dev</key><value>2.5e3</value></param>
</block>
<block>
<key>pfb_arb_resampler_xxx</key>
<param><key>id</key><value>pfb_arb_resampler_xxx_4</value></param>
<param><key>type</key><value>fff</value></param>
<param><key>rrate</key><value>16000/44100.0</value></param>
<param><key>nfilts</key><value>32</value></param>
<param><key>atten</key><value>100</value></param>
</block>
<block>
<key>blocks_wavfile_sink</key>
<param><key>id</key><value>blocks_wavfile_sink_0</value></param>
<param><key>file</key><value>testps.wav</value></param>
<param><key>samp_rate</key><value>16000</value></param>
<param><key>bits_per_sample</key><value>16</value></param>
</block>
<block>
<key>analog_nbfm_rx</key>
<param><key>id</key><value>analog_nbfm_rx_1</value></param>
<param><key>audio_rate</key><value>44100</value></param>
<param><key>quad_rate</key><value>44100</value></param>
<param><key>tau</key><value>75e-6</value></param>
<param><key>max_dev</key><value>2.5e3</value></param>
</block>
<block>
<key>pfb_arb_resampler_xxx</key>
<param><key>id</key><value>pfb_arb_resampler_xxx_4_0</value></param>
<param><key>type</key><value>fff</value></param>
<param><key>rrate</key><value>16000/44100.0</value></param>
<param><key>nfilts</key><value>32</value></param>
<param><key>atten</key><value>100</value></param>
</block>
<block>
<key>blocks_wavfile_sink</key>
<param><key>id</key><value>blocks_wavfile_sink_0_0</value></param>
<param><key>file</key><value>testsea.wav</value></param>
<param><key>samp_rate</key><value>16000</value></param>
<param><key>bits_per_sample</key><value>16</value></param>
</block>
<block>
<key>rtlsdr_source</key>
<param><key>id</key><value>rtlsdr_source_0</value></param>
<param><key>type</key><value>fc32</value></param>
<param><key>args</key><value></value></param>
<param><key>sample_rate</key><value>samp_rate</value></param>
<param><key>freq0</key><value>162.4875e6</value></param>
<param><key>corr0</key><value>50</value></param>
<param><key>gain_mode0</key><value>False</value></param>
<param><key>gain0</key><value>49.6</value></param>
<param><key>if_gain0</key><value>49.6</value></param>
<param><key>bb_gain0</key><value>49.6</value></param>
</block>
<connection><source_block_id>analog_nbfm_rx_1_0</source_block_id><sink_block_id>audio_sink_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>rtlsdr_source_0</source_block_id><sink_block_id>freq_xlating_fir_filter_xxx_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>rtlsdr_source_0</source_block_id><sink_block_id>freq_xlating_fir_filter_xxx_1</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>rtlsdr_source_0</source_block_id><sink_block_id>wxgui_waterfallsink2_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>analog_nbfm_rx_1</source_block_id><sink_block_id>audio_sink_0_0</sink_block_id><source_key>0</source_key><sink_key>1</sink_key></connection>
<connection><source_block_id>same_same_decode_fb_0</source_block_id><sink_block_id>blocks_file_sink_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>same_same_decode_fb_0_0</source_block_id><sink_block_id>blocks_file_sink_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>freq_xlating_fir_filter_xxx_0</source_block_id><sink_block_id>pfb_arb_resampler_xxx_1</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>pfb_arb_resampler_xxx_1</source_block_id><sink_block_id>analog_nbfm_rx_1_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>freq_xlating_fir_filter_xxx_1</source_block_id><sink_block_id>pfb_arb_resampler_xxx_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>pfb_arb_resampler_xxx_0</source_block_id><sink_block_id>analog_nbfm_rx_1</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>analog_nbfm_rx_1</source_block_id><sink_block_id>pfb_arb_resampler_xxx_3</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>pfb_arb_resampler_xxx_3</source_block_id><sink_block_id>same_same_decode_fb_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>analog_nbfm_rx_1_0</source_block_id><sink_block_id>pfb_arb_resampler_xxx_2</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>pfb_arb_resampler_xxx_2</source_block_id><sink_block_id>same_same_decode_fb_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>analog_nbfm_rx_1_0</source_block_id><sink_block_id>pfb_arb_resampler_xxx_4</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>pfb_arb_resampler_xxx_4</source_block_id><sink_block_id>blocks_wavfile_sink_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>pfb_arb_resampler_xxx_4_0</source_block_id><sink_block_id>blocks_wavfile_sink_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>analog_nbfm_rx_1</source_block_id><sink_block_id>pfb_arb_resampler_xxx_4_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
</flow_graph>
